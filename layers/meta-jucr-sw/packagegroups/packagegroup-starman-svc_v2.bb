DESCRIPTION = "My Custom Package Groups"
inherit packagegroup

RDEPENDS:${PN} = "\
  starman-v2-svc-cfg \
"
