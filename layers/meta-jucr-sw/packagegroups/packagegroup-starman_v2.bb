DESCRIPTION = "Starman v2 all package groups (fw,sw,svcs)"

inherit packagegroup

PACKAGES = "\
 packagegroup-starman-v2-fw \
 packagegroup-starman-v2-sw \
 packagegroup-starman-v2-svc \
"

